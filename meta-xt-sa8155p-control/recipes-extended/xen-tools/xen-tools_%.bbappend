RRECOMMENDS:${PN}:remove = "qemu"
